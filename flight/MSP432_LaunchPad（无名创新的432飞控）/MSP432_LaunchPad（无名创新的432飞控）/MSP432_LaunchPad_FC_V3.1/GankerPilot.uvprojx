# Keil uVision project GankerPilot.uvprojx, settings and files
target GankerPilot_Pro (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gankerpilot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __MSP432P401R__,ARM_MATH_CM4
  c include: .\source;.\source\third_party\CMSIS\Include;.\User;.\User\Driver\Src;.\User\Controler\Src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group chip
    ./source/ti/devices/msp432p4xx/driverlib/: adc14.c cpu.c cs.c dma.c flash.c fpu.c gpio.c i2c.c interrupt.c ref_a.c sysctl.c systick.c timer_a.c timer32.c uart.c wdt_a.c
  group user
    ./User/: main.c
  group driver
    ./User/Driver/Src/: Bling.c Calibration.c Filter.c Key.c mpu6050.c myiic.c OLED.c PID.c PPM.c RC.c Ringbuf.c SINS.c SPL06.c ssd1306.c SYSTEM.c Time.c Time_Cnt.c US_100.c Usart.c WP_ADC.c wp_flash.c WP_Math.c WP_PWM.c IST8310.c OpticalFlow_LC306.c Soft_I2C.c tfmini.c license.o stflash.c softiic.c GY53L1X.c QMC5883.c
  group control
    ./User/Controler/Src/: CalibrationRoutines.c control_althold.c control_land.c control_poshold.c Earth_Declination.c NamelessCotrun_SDK.c OpticalFlow_Control.c Sensor.c WP_Ctrl.c Temperature_Ctrl.c NamelessCorun_OpticalFlow.c Compass.c NCLink.c madgwick.c ADRC.c ADRC.h Developer_Mode.c
software components: CMSIS:CORE 5.1.2, Device:Startup 3.2.2
